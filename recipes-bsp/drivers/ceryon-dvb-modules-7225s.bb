KV = "4.10.12"
SRCDATE = "20181211"
MACHINETYPE = "7225s"

require ceryon-dvb-modules.inc
SRC_URI[md5sum] = "9d69b9e65ce29cd1b74998073a4c8fe4"
SRC_URI[sha256sum] = "da39faf6f76a42c80ffe7b7db10d6bee055add54df5ccdd6023b1cb6eee9cc09"

COMPATIBLE_MACHINE = "9911lx|e4hdcombo|9920lx"
